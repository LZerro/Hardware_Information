<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ITM_printf_TG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Trace_and_ITM_printf_GG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Trace_Problem_GG.ewp</path>
  </project>

  <batchBuild/>
</workspace>
