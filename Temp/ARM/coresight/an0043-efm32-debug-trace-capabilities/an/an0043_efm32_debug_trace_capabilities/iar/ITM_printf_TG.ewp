# IAR project ITM_printf_TG.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ITM_printf_TG.bin
  ILINK.IlinkOutputFile: ITM_printf_TG.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../kits/common/drivers/: retargetio.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Source
    ../: debug_printf.c
