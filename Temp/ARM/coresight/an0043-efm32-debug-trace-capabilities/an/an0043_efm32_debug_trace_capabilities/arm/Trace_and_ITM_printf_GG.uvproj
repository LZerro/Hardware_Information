# Keil uVision project Trace_and_ITM_printf_GG.uvproj, settings and files
target Trace_and_ITM_printf_GG (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: Trace_and_ITM_printf_GG
  AfterMake: fromelf.exe --bin --output obj\Trace_and_ITM_printf_GG.bin obj\Trace_and_ITM_printf_GG.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32GG_DK3750\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers
    ../../../kits/common/drivers/: retargetio.c
  group BSP
    ../../../kits/common/bsp/: bsp_trace.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group Source
    ../: etm_trace_debug_printf.c
