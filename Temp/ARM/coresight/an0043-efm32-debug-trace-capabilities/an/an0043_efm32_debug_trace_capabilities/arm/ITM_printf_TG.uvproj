# Keil uVision project ITM_printf_TG.uvproj, settings and files
target ITM_printf_TG (ARM-ADS)
  device: EFM32TG840F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: ITM_printf_TG
  AfterMake: fromelf.exe --bin --output obj\ITM_printf_TG.bin obj\ITM_printf_TG.axf
  c flags: Optim=1 oTime=1
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32TG\Include;..\..\..\emlib\inc;..\..\..\kits\common\drivers
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers
    ../../../kits/common/drivers/: retargetio.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Source
    ../: debug_printf.c
